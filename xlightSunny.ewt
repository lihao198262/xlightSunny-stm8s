<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>STM8S Library</name>
    <file>
      <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_clk.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_exti.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_flash.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_gpio.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_spi.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_tim1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_tim1.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_tim2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_tim2.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_tim3.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_tim3.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_tim4.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_tim4.h</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\_global.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\LightPwmDrv.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\MyMessage.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\ProtocolParser.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\ProtocolParser.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\rf24l01.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\rf24l01.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\stm8s_conf.h</name>
  </file>
  <file>
    <name>$PROJ_DIR$\stm8s_it.h</name>
  </file>
</project>


